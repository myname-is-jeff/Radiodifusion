options:
  parameters:
    author: Bauti
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: lpf
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 1.2e6
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samples_per_line * 60 * .999 * 525 / 2
  states: {}
- name: samples_per_line
  id: variable
  parameters:
    value: '772'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: Aca filtro la banda vestigial
    decim: '1'
    gain: '1'
    high_cutoff_freq: 4.2e6
    low_cutoff_freq: '-750e3'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 500e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      El filtro va a ingresar una demora por que se deberá ajustas
      Para que las señales se vean correctamente
    delay: int((len(lpf)-1)/2)
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Bauti\Desktop\Facu\Radiodifusion\Radiodifusion\G3\Barras.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: |-
      Este es pasa bajos para filtrar la crominancia y 
      que quede solo la luminancia
    decim: '1'
    taps: lpf
    type: fff
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Si utilizo una transición más baja (mas agresiva) se traba todo, 
      igual considero que 15khz esta bastante bien
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Video compuesto
    label2: Luminancia
    name: '"Video Compuesto mod negativa"'
    nconnections: '2'
    size: 4096*3
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymin: '-0.5'
  states: {}

connections:
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
