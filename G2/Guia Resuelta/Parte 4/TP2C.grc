options:
  parameters:
    author: Bauti
    generate_options: qt_gui
    id: TP2A
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: deltaF
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*np.pi*deltaF)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Bauti\Desktop\Facu\Radiodifusion\Radiodifusion\G2\Guia Resuelta\Parte 4\radio_240k.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    norm_window: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    freqhalf: 'False'
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
