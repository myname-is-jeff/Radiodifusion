options:
  parameters:
    author: Bauti
    generate_options: qt_gui
    id: TP2A
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: deltaF
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: 1e6
    value: '400000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*deltaF)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Bauti\Desktop\Facu\Radiodifusion\Radiodifusion\G2\Guia Resuelta\Parte 4\espectro_2M
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fc
    decim: '1'
    samp_rate: samp_rate
    taps: '[-0.0036494527012109756,-0.0031824284233152866,-1.570126914884895e-05,0.007361589930951595,0.016094394028186798,0.01699167490005493,-5.472940028994344e-05,-0.03480949252843857,-0.06826717406511307,-0.06670834124088287,-0.00010339670552639291,0.1349414587020874,0.3038255274295807,0.44504112005233765,0.5000977516174316,0.44504112005233765,0.3038255274295807,0.1349414587020874,-0.00010339670552639291,-0.06670834124088287,-0.06826717406511307,-0.03480949252843857,-5.472940028994344e-05,0.01699167490005493,0.016094394028186798,0.007361589930951595,-1.570126914884895e-05,-0.0031824284233152866,-0.0036494527012109756]'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    norm_window: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"Señal Salida Q_DMOD"'
    norm_window: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"Señal Entrada"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"Señal Salida Q_DMOD"'
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', audio_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
