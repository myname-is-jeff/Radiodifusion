options:
  parameters:
    author: Bauti
    generate_options: qt_gui
    id: TP2A
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: deltaF
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Bauti\Desktop\Facu\Radiodifusion\Radiodifusion\G2\Guia Resuelta\Parte 4\signal_2_5e+06_2.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '2500'
    vlen_out: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '2500'
    max_iter: '4000'
    scale: 1/2500
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/(2*np.pi)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2500'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: sqrt
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    norm_window: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"RMS"'
    name: '"RMS"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"PICO"'
    name: '"Pico"'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: qdmod_in
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: qdmod_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: qdmod_in
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: qdmod_out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: qdmod_out
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_max_xx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_1, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_max_xx_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_transcendental_0, '0', qtgui_number_sink_0, '0']
- [virtual_source_0, '0', blocks_delay_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_1_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
