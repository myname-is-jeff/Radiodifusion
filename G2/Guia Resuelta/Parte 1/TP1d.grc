options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Bauti\Desktop\Facu\Radiodifusion\Radiodifusion\G2\Guia Resuelta\espectro_2M.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      La relacion entre el sample rate y el bandwith es que al estar muestreando una señal compleja, 
      el ancho de banda se vuelve +/- samp_rate/2 con la frecuencia que se quiere observar en el centro.
      Entonces, cuanto mayor sea la frecuencia donte te estes parando, menos ancho de banda vas a tener
      y menos información vas a poder ver amenos se aumente la frecuencia de muestreo.
      De esta forma no se viola nysquist.

      Suponiendo que las emisoras son los picos de mayor ganancia,
      se pueden observar 5 emisoras; 94.2, 94.7, 95.1,95.5, 95.8
    note: RTA
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 95.1e6
    fftsize: '2048'
    grid: 'True'
    name: ''
    norm_window: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
